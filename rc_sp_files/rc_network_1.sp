* RC Network with Randomized Components
.title Random RC Network
.global vdd

* Voltage source
V1 IN 0 PULSE(0 1 0 1n 1n 50n 100n)

* RC Network
R1 IN n1 211.925
C1 n1 0 1.370e-10
R2 n1 n2 62.581
C2 n2 0 1.455e-10
R3 n2 n3 41.405
C3 n3 0 9.203e-11
R4 n3 n4 114.244
C4 n4 0 4.514e-10
R5 n4 n5 592.171
C5 n5 0 3.180e-10
R6 n5 n6 738.285
C6 n6 0 7.280e-10
R7 n6 n7 198.253
C7 n7 0 4.559e-10
R8 n7 n8 567.479
C8 n8 0 2.207e-10
R9 n8 n9 570.815
C9 n9 0 7.966e-10
R10 n9 n10 143.19
C10 n10 0 9.365e-10
R11 n10 n11 358.562
C11 n11 0 7.791e-10
R12 n11 n12 103.265
C12 n12 0 1.576e-10
R13 n12 n13 561.335
C13 n13 0 6.792e-10
R14 n13 n14 906.095
C14 n14 0 4.104e-10
R15 n14 n15 261.259
C15 n15 0 6.828e-11
R16 n15 n16 974.862
C16 n16 0 7.649e-10
R17 n16 n17 176.714
C17 n17 0 1.883e-10
R18 n17 n18 163.25
C18 n18 0 9.766e-10
R19 n18 n19 868.727
C19 n19 0 2.671e-10
R20 n19 n20 849.472
C20 n20 0 2.631e-10
R21 n20 n21 968.291
C21 n21 0 8.958e-10
R22 n21 n22 24.623
C22 n22 0 9.061e-10
R23 n22 n23 102.045
C23 n23 0 9.698e-10
R24 n23 n24 570.559
C24 n24 0 5.070e-10
R25 n24 n25 911.495
C25 n25 0 2.898e-10
R26 n25 n26 670.273
C26 n26 0 2.388e-10
R27 n26 n27 278.434
C27 n27 0 7.197e-10
R28 n27 n28 468.079
C28 n28 0 9.344e-10
R29 n28 n29 268.291
C29 n29 0 9.947e-10
R30 n29 n30 58.789
C30 n30 0 8.983e-10
R31 n30 n31 783.315
C31 n31 0 6.102e-10
R32 n31 n32 384.376
C32 n32 0 8.629e-10
R33 n32 n33 392.838
C33 n33 0 6.322e-10
R34 n33 n34 329.21
C34 n34 0 3.017e-10
R35 n34 n35 321.453
C35 n35 0 1.836e-10
R36 n35 n36 622.439
C36 n36 0 1.861e-10
R37 n36 n37 934.109
C37 n37 0 4.062e-10
R38 n37 n38 118.836
C38 n38 0 2.932e-10
R39 n38 n39 164.235
C39 n39 0 6.498e-10
R40 n39 n40 458.721
C40 n40 0 1.564e-10
R41 n40 n41 19.929
C41 n41 0 1.463e-10
R42 n41 n42 983.971
C42 n42 0 1.435e-10
R43 n42 n43 517.02
C43 n43 0 3.700e-10
R44 n43 n44 223.849
C44 n44 0 1.767e-11
R45 n44 n45 654.513
C45 n45 0 7.635e-10
R46 n45 n46 870.879
C46 n46 0 3.229e-10
R47 n46 n47 201.419
C47 n47 0 6.863e-11
R48 n47 n48 612.453
C48 n48 0 7.903e-10
R49 n48 n49 337.302
C49 n49 0 9.257e-10
R50 n49 n50 907.953
C50 n50 0 9.337e-10
R51 n50 n51 978.629
C51 n51 0 3.807e-10
R52 n51 n52 14.313
C52 n52 0 6.344e-10
R53 n52 n53 700.313
C53 n53 0 6.978e-10
R54 n53 n54 186.292
C54 n54 0 2.228e-10
R55 n54 n55 22.578
C55 n55 0 9.185e-10
R56 n55 n56 378.465
C56 n56 0 8.455e-10
R57 n56 n57 930.076
C57 n57 0 6.075e-10
R58 n57 n58 748.23
C58 n58 0 1.588e-11
R59 n58 n59 855.937
C59 n59 0 4.893e-10
R60 n59 n60 321.663
C60 n60 0 6.984e-10
R61 n60 n61 356.368
C61 n61 0 8.882e-10
R62 n61 n62 15.195
C62 n62 0 2.298e-10
R63 n62 n63 254.653
C63 n63 0 8.312e-10
R64 n63 n64 829.994
C64 n64 0 4.824e-10
R65 n64 n65 244.017
C65 n65 0 2.794e-10
R66 n65 n66 203.766
C66 n66 0 9.046e-10
R67 n66 n67 338.401
C67 n67 0 8.189e-10
R68 n67 n68 784.875
C68 n68 0 2.593e-10
R69 n68 n69 374.625
C69 n69 0 2.841e-10
R70 n69 n70 444.9
C70 n70 0 4.817e-10
R71 n70 n71 903.037
C71 n71 0 4.316e-10
R72 n71 n72 142.803
C72 n72 0 4.543e-10
R73 n72 n73 740.243
C73 n73 0 5.596e-11
R74 n73 n74 29.334
C74 n74 0 3.116e-10
R75 n74 n75 640.075
C75 n75 0 9.463e-10
R76 n75 n76 655.67
C76 n76 0 6.098e-10
R77 n76 n77 966.407
C77 n77 0 7.812e-10
R78 n77 n78 126.378
C78 n78 0 9.268e-10
R79 n78 n79 681.065
C79 n79 0 7.191e-10
R80 n79 n80 614.575
C80 n80 0 6.609e-11
R81 n80 n81 135.472
C81 n81 0 3.915e-10
R82 n81 n82 613.031
C82 n82 0 4.853e-10
R83 n82 n83 255.062
C83 n83 0 9.895e-10
R84 n83 n84 145.65
C84 n84 0 5.478e-10
R85 n84 n85 790.397
C85 n85 0 5.895e-10
R86 n85 n86 173.067
C86 n86 0 3.304e-10
R87 n86 n87 229.057
C87 n87 0 1.519e-10
R88 n87 n88 627.411
C88 n88 0 4.501e-10
R89 n88 n89 784.473
C89 n89 0 1.362e-10
R90 n89 n90 571.217
C90 n90 0 5.139e-10
R91 n90 n91 130.535
C91 n91 0 8.602e-10
R92 n91 n92 783.683
C92 n92 0 8.200e-10
R93 n92 n93 774.301
C93 n93 0 2.258e-11
R94 n93 n94 440.887
C94 n94 0 3.739e-10
R95 n94 n95 960.608
C95 n95 0 5.639e-10
R96 n95 n96 725.037
C96 n96 0 3.468e-10
R97 n96 n97 498.3
C97 n97 0 8.492e-10
R98 n97 n98 669.396
C98 n98 0 8.818e-10
R99 n98 n99 526.335
C99 n99 0 9.632e-10
R100 n99 n100 389.592
C100 n100 0 8.025e-10
R101 n100 n101 754.956
C101 n101 0 7.914e-10
R102 n101 n102 844.917
C102 n102 0 1.981e-10
R103 n102 n103 311.231
C103 n103 0 5.482e-10
R104 n103 n104 618.716
C104 n104 0 8.223e-10
R105 n104 n105 819.573
C105 n105 0 1.195e-10
R106 n105 n106 951.208
C106 n106 0 3.363e-10
R107 n106 n107 140.782
C107 n107 0 4.105e-10
R108 n107 n108 326.334
C108 n108 0 8.095e-10
R109 n108 n109 45.265
C109 n109 0 9.114e-10
R110 n109 n110 161.723
C110 n110 0 9.251e-10
R111 n110 n111 836.068
C111 n111 0 1.565e-10
R112 n111 n112 904.405
C112 n112 0 6.280e-10
R113 n112 n113 555.866
C113 n113 0 5.680e-10
R114 n113 n114 754.696
C114 n114 0 6.378e-12
R115 n114 n115 982.032
C115 n115 0 8.889e-10
R116 n115 n116 371.612
C116 n116 0 3.813e-11
R117 n116 n117 799.071
C117 n117 0 5.105e-10
R118 n117 n118 150.649
C118 n118 0 4.303e-10
R119 n118 n119 748.019
C119 n119 0 6.184e-11
R120 n119 n120 842.679
C120 n120 0 9.362e-10
R121 n120 n121 435.061
C121 n121 0 4.167e-10
R122 n121 n122 687.733
C122 n122 0 5.162e-10
R123 n122 n123 779.462
C123 n123 0 7.644e-10
R124 n123 n124 956.454
C124 n124 0 1.024e-10
R125 n124 n125 140.21
C125 n125 0 6.512e-10
R126 n125 n126 679.149
C126 n126 0 1.802e-10
R127 n126 n127 385.812
C127 n127 0 9.063e-10
R128 n127 n128 827.095
C128 n128 0 5.539e-10
R129 n128 n129 618.565
C129 n129 0 6.947e-10
R130 n129 n130 575.727
C130 n130 0 3.546e-10
R131 n130 n131 698.818
C131 n131 0 7.293e-10
R132 n131 n132 977.075
C132 n132 0 9.610e-10
R133 n132 n133 89.582
C133 n133 0 5.368e-10
R134 n133 n134 847.303
C134 n134 0 1.148e-10
R135 n134 n135 690.699
C135 n135 0 3.401e-10
R136 n135 n136 574.083
C136 n136 0 3.905e-10
R137 n136 n137 409.017
C137 n137 0 8.647e-10
R138 n137 n138 285.584
C138 n138 0 9.532e-10
R139 n138 n139 543.392
C139 n139 0 9.550e-10
R140 n139 n140 190.288
C140 n140 0 4.166e-10
R141 n140 n141 527.399
C141 n141 0 9.735e-10
R142 n141 n142 867.515
C142 n142 0 7.550e-10
R143 n142 n143 809.801
C143 n143 0 5.287e-10
R144 n143 n144 47.299
C144 n144 0 6.482e-11
R145 n144 n145 788.977
C145 n145 0 1.359e-10
R146 n145 n146 923.244
C146 n146 0 6.191e-10
R147 n146 n147 972.241
C147 n147 0 9.318e-10
R148 n147 n148 940.429
C148 n148 0 6.937e-10
R149 n148 n149 930.388
C149 n149 0 9.324e-10
R150 n149 n150 579.101
C150 n150 0 7.288e-11
R151 n150 n151 479.068
C151 n151 0 7.641e-10
R152 n151 n152 44.325
C152 n152 0 5.845e-10
R153 n152 n153 361.178
C153 n153 0 6.940e-10
R154 n153 n154 75.556
C154 n154 0 6.397e-10
R155 n154 n155 886.02
C155 n155 0 2.423e-10
R156 n155 n156 641.921
C156 n156 0 8.632e-10
R157 n156 n157 930.299
C157 n157 0 1.461e-10
R158 n157 n158 642.26
C158 n158 0 6.723e-10
R159 n158 n159 818.748
C159 n159 0 7.815e-10
R160 n159 n160 952.1
C160 n160 0 2.582e-11
R161 n160 n161 169.373
C161 n161 0 3.476e-10
R162 n161 n162 526.142
C162 n162 0 9.995e-10
R163 n162 n163 16.215
C163 n163 0 4.095e-10
R164 n163 n164 774.842
C164 n164 0 8.147e-10
R165 n164 n165 617.899
C165 n165 0 7.309e-10
R166 n165 n166 275.783
C166 n166 0 6.351e-11
R167 n166 n167 721.873
C167 n167 0 6.465e-10
R168 n167 n168 13.0
C168 n168 0 8.504e-10
R169 n168 n169 408.559
C169 n169 0 3.442e-10
R170 n169 n170 555.706
C170 n170 0 1.364e-10
R171 n170 n171 662.052
C171 n171 0 8.006e-12
R172 n171 n172 488.901
C172 n172 0 6.726e-10
R173 n172 n173 734.008
C173 n173 0 4.722e-10
R174 n173 n174 242.797
C174 n174 0 8.828e-10
R175 n174 n175 835.597
C175 n175 0 6.129e-10
R176 n175 n176 449.65
C176 n176 0 8.828e-10
R177 n176 n177 114.524
C177 n177 0 8.467e-10
R178 n177 n178 101.815
C178 n178 0 1.054e-10
R179 n178 n179 64.287
C179 n179 0 5.503e-10
R180 n179 n180 921.03
C180 n180 0 1.235e-10
R181 n180 n181 821.716
C181 n181 0 3.656e-10
R182 n181 n182 93.315
C182 n182 0 5.869e-10
R183 n182 n183 380.319
C183 n183 0 5.131e-10
R184 n183 n184 868.261
C184 n184 0 5.446e-10
R185 n184 n185 357.021
C185 n185 0 3.529e-10
R186 n185 n186 714.878
C186 n186 0 9.815e-10
R187 n186 n187 796.014
C187 n187 0 6.747e-10
R188 n187 n188 725.161
C188 n188 0 1.621e-10
R189 n188 n189 334.718
C189 n189 0 7.385e-10
R190 n189 n190 396.243
C190 n190 0 8.941e-10
R191 n190 n191 763.933
C191 n191 0 3.578e-11
R192 n191 n192 37.361
C192 n192 0 7.342e-10
R193 n192 n193 146.695
C193 n193 0 4.644e-11
R194 n193 n194 183.809
C194 n194 0 5.381e-10
R195 n194 n195 996.909
C195 n195 0 1.612e-10
R196 n195 n196 490.459
C196 n196 0 5.178e-10
R197 n196 n197 565.31
C197 n197 0 4.162e-10
R198 n197 n198 566.146
C198 n198 0 8.376e-10
R199 n198 n199 450.646
C199 n199 0 2.238e-10
R200 n199 n200 752.165
C200 n200 0 8.906e-10

* Simulation Settings
.option post accurate probe nomod
.tran 1n 20u
.print tran V(n200)
.end
